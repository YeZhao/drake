Commit message: add torque comp tests and clean kuka plant files

File: drake/examples/kuka_iiwa_arm/urdf/iiwa14_estimated_params.urdf (robot description, URDF)
Before this commit: robot iiwa14, 11 links, 10 joints
Links:
- link iiwa_link_2: mass 6.15 -> 6.35
